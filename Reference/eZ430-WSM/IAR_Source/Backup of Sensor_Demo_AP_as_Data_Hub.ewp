# IAR project Backup of Sensor_Demo_AP_as_Data_Hub.ewp, settings and files
configuration CC2500 Sensor Demo-Access Point (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2500
  ICC430.IExtraOptions: -f"Configuration\Access_Point\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Components\bsp; Components\bsp\drivers; Components\bsp\boards\EZ430RF; Components\mrfi; Components\SimpliciTI\nwk; Components\SimpliciTI\nwk_applications
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: --ks_version
configuration CC2500 Sensor Demo-End Device (MSP430, debug)
  as the first configuration, except:
  ICC430.IExtraOptions: -f"Configuration\End_Device\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  group Components/bsp
    Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_security.c
    Components/SimpliciTI/nwk_applications/: nwk_freq.h nwk_ioctl.h nwk_join.h nwk_link.h nwk_mgmt.h nwk_ping.h nwk_security.h
  group peer applications/application
    Applications/: virtual_com_cmds.c virtual_com_cmds.h vlo_rand.h vlo_rand.s43
  group peer applications/application/Access Point
    Applications/: main_AP.c
  group peer applications/application/End Device
    Applications/: main_ED.c
  group peer applications/Configuration
    Projects/Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/Access Point
    Projects/Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/End Device
    Projects/Configuration/End_Device/: smpl_config.dat
