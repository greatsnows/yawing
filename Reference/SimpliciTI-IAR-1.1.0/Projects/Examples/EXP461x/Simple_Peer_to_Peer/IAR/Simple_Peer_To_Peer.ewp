# IAR project Simple_Peer_To_Peer.ewp, settings and files
configuration CC1100-LinkTo (MSP430, debug)
  General.OGChipSelectMenu: MSP430FG4618 MSP430FG4618
  General.GStackSize2: 200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC1100
  ICC430.IExtraOptions: -f"Configuration\End_Device\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\EXP461x; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FG4618.xcl
  XLINK.XlinkStackSize: 1
configuration CC1100-LinkListen (MSP430, debug)
  as the first configuration, except:
configuration CC1101-Linkto (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1101
configuration CC1101-LinkListen (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1101
configuration CC1100E-LinkTo (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1100E_470; xMRFI_CC1100E_950
configuration CC1100E-LinkListen (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC1100E_470; xMRFI_CC1100E_950
configuration CC2500-LinkTo (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC2500
configuration CC2500-LinkListen (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MRFI_CC2500
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
    ../../../../../Components/SimpliciTI/nwk/: nwk_globals.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
  group peer applications/application/LinkListen
    ../../../Applications/: main_LinkListen.c
  group peer applications/application/LinkTo
    ../../../Applications/: main_LinkTo.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
