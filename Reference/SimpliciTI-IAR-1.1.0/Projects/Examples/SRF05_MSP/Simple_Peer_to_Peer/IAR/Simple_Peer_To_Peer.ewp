# IAR project Simple_Peer_To_Peer.ewp, settings and files
configuration CC2520-LinkTo (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC2520
  ICC430.IExtraOptions: -f"Configuration\End_Device\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\SRF05EB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration CC2520-LinkListen (MSP430, debug)
  as the first configuration, except:
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../../../Components/bsp/boards/SRF05EB/: DCO_calibrate.h DCO_calibrate.s43
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
    ../../../../../Components/SimpliciTI/nwk/: nwk_globals.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
  group peer applications/application/LinkListen
    ../../../Applications/: main_LinkListen.c
  group peer applications/application/LinkTo
    ../../../Applications/: main_LinkTo.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
