<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\My_SPtP\mySPtP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Simple_Peer_To_Peer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Devices</name>
      <member>
        <project>Simple_Peer_To_Peer</project>
        <configuration>CC2500-LinkTo</configuration>
      </member>
      <member>
        <project>Simple_Peer_To_Peer</project>
        <configuration>CC2500-LinkListen</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


